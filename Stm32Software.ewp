# IAR project Stm32Software.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: $PROJ_DIR$; Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; Libraries\CMSIS\CM3\CoreSupport; Libraries\STM32F10x_StdPeriph_Driver\inc; GUI\AntiAlias; GUI\GUI_Config; GUI\GUI_inc; GUI\GUI_X; GUI\Demo; GUI\GUI_TASK; user
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Stm32Software.hex
  ILINK.IlinkOutputFile: Stm32Software.out
  ILINK.IlinkIcfFile: EVARM\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group CMSIS
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group EVARM
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
  group StdPeriph_Driver
    Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    User/: Bottom.c HZFont.C Logic.c Variable.c
    ./: main.c stm32f10x_it.c
    Libraries/STM32F10x_StdPeriph_Driver/inc/: MyHeader.h
